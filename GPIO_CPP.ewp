# IAR project GPIO_CPP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: GPIO_CPP.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: Counter.h Def.h GPIO.h HMI.h main.cpp ModCounter.h Motor.cpp Motor.h UserButton.h UserLED.cpp UserLED.h
